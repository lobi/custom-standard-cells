* NGSPICE file created from buffer.ext - technology: sky130A

.subckt buffer A Y VDD GND
X0 Y a_50_n100# GND GND sky130_fd_pr__nfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
X1 a_50_n100# A VDD VDD sky130_fd_pr__pfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
X2 Y a_50_n100# VDD VDD sky130_fd_pr__pfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
X3 a_50_n100# A GND GND sky130_fd_pr__nfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
.ends
