* NGSPICE file created from inverter.ext - technology: sky130A

.subckt inverter A Y VDD GND
X0 Y A GND GND sky130_fd_pr__nfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
X1 Y A VDD VDD sky130_fd_pr__pfet_01v8 ad=0.525 pd=3.1 as=0.525 ps=3.1 w=1.05 l=0.15
.ends
